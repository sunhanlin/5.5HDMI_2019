# Keil uVision project IAP_USB.uvproj, settings and files
target IAP_USB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP_USB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USER;..\USB\Mass_Storage\inc;..\USB\USBLIB\inc;..\HARDWARE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\stmflash;..\HARDWARE\tft
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_fsmc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/tft/: fontupd.c lcd_drive.c lcd_tft.c
  group USBLIB
    ../USB/USBLIB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ../USB/Mass_Storage/src/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c dfu_mal.c
